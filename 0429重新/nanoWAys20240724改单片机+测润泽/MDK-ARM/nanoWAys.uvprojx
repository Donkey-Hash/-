# Keil uVision project nanoWAys.uvprojx, settings and files
target nanoWAys (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: nanoWAys +hex
  AfterMake: fromelf --bin --output .\nanoWAys\nanoWAys.bin .\nanoWAys\nanoWAys.axf
  c flags: Optim=1 OneElfS=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,USE_FULL_LL_DRIVER,USER_VECT_TAB_ADDRESS,__TARGET_FPU_VFP, ARM_MATH_CM4
  c misc: --C99
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../USB_HOST/App;../USB_HOST/Target;../Middlewares/ST/STM32_USB_Host_Library/Class/MTP/Inc;../Bsp/inc;../ExDev/inc;../FreeModbus;../FreeModbus/modbus/include;../FreeModbus/port;../FreeModbus/modbus/rtu;../Tasks/inc;../AnalysisProc/inc;../Inc;../encrypt/inc;../../nanoWAmpw/encrypt/inc;E:/resources/stm32/SEGGER/SEGGER_RTT_V630b/RTT;..\MDK-ARM
  asm include: ..\Core\Inc;..\Inc
  memory RVCT4: ROM 0x8040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Modbus
    ../FreeModbus/port/: port.c portevent.c portserial.c porttimer.c
    ../FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c mbfuncblock.c mbfuncpseudomaster.c
    ../FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../FreeModbus/modbus/: mb.c Modbus.c
  group BSP
    ../Bsp/src/: FlashUserData.c mtimers.c peristalticpump.c progressbar.c replyhost.c valve.c pid.c TestLEDCtr.c stm32f4flashopt.c ModbusMaster.c ADS1220.c STMcalendar.c
    ./: Clock.h Clock.c modbusdata_mb3.c
  group ExDev
    ../ExDev/src/: OPT2000.c ysspectro.c yssyringepump.c syringepump.c
  group Tasks
    ../Tasks/src/: uartsrxtask.c processcontroltask.c tempcontroltask.c datacollecttask.c stirtask.c
    ./: errormanagetask.c
  group AnalysisProc
    ../AnalysisProc/src/: instrumentinfo.c ProcAPI.c ProcCODCl.c ProcCODCr.c ProcCODMn.c ProcCommon.c ProcNH_II.c ProcTN.c ProcTP.c ProcTNR.c
  group Readme
    ../: readme.txt
  group Application/User
    ../Src/: main.c gpio.c freertos.c adc.c dac.c dma.c iwdg.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group entript
    ../lib/: encryptmcu.lib
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_gpio.c stm32f4xx_ll_adc.c stm32f4xx_ll_dma.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_dac.c stm32f4xx_ll_rtc.c stm32f4xx_ll_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c
software components: CMSIS:CORE 5.5.0
